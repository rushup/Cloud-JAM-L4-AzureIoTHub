# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F4XX_NUCLEO; OSX_BMS_NUCLEO
  ICCARM.CCDiagSuppress: Pa50
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BootLoaderF429.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BootLoader/EWARM
    ./: startup_stm32f429xx.s
  group BootLoader/User
    ../../Src/: main.c stm32f4xx_it.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
