# IAR project Project.ewp, settings and files
configuration mbedTLS (ARM)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; NO_LOGGING=1; EINVAL=-1; ENOMEM=EINVAL; USE_GENERICACCESSKEY_IOTHUB=0; REFCOUNT_ATOMIC_DONTCARE=1; DONT_USE_UPLOADTOBLOB=1; USE_MBED_TLS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\Components\M24SR; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-umqtt-c\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\iothub_client\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\azure-c-shared-utility\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\serializer\inc; ..\..\..\..\..\..\Middlewares\Third_Parties\AzureIOT\parson; ..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\..\Middlewares\Third_Parties\mbedtls\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Azure_Sns_DM.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Azure_Sns_DM/EWARM
    ./: startup_stm32l476xx.s
  group Azure_Sns_DM/User
    ../../Src/: AzureClient_mqtt_DM_TM.c console.c HWAdvanceFeatures.c main.c OTA.c RegistrationAgent.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Azure_Sns_DM/User/adapters
    ../../Src/: agenttime_STM32Cube.c platform_STM32Cube.c socketio_STM32Cube.c tickcounter_STM32Cube.c
  group Azure_Sns_DM/User/adapters/socketio
    ../../Src/: tcpsocketSTM32Cube.c
  group Azure_Sns_DM/User/adapters/STM32CubeInterface
    ../../Src/: STM32CubeRTCInterface.c timingSystem.c
  group Azure_Sns_DM/User/adapters/tlsio_STM32Cube
    ../../Src/: TLocalBuffer.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
  group Drivers/BSP/Components/IKS01A1
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group Drivers/BSP/Components/IKS01A2
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_I2C.c stm32l4xx_nucleo.c stm32l4xx_UART.c
  group Drivers/BSP/X-NUCLEO-IDW01M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/AzureIOT/azure-c-shared-utility/src
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-c-shared-utility/src/: base64.c buffer.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gb_stdio.c gb_time.c gballoc.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c list.c map.c optionhandler.c sastoken.c sha1.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c tlsio_mbedtls.c tlsio_openssl.c tlsio_schannel.c tlsio_wolfssl.c urlencode.c usha.c vector.c x509_schannel.c xio.c xlogging.c
  group Middlewares/AzureIOT/iothub_client/mqtt_sample
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/sample/: iothub_client_sample_mqtt.c
  group Middlewares/AzureIOT/iothub_client/src
    ../../../../../../Middlewares/Third_Parties/AzureIOT/iothub_client/src/: blob.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_message.c iothubtransport.c iothubtransport_mqtt_common.c iothubtransportamqp.c iothubtransportamqp_websockets.c iothubtransporthttp.c iothubtransportmqtt.c version.c
  group Middlewares/AzureIOT/mqtt
    ../../../../../../Middlewares/Third_Parties/AzureIOT/azure-umqtt-c/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/AzureIOT/parson
    ../../../../../../Middlewares/Third_Parties/AzureIOT/parson/: parson.c
  group Middlewares/AzureIOT/serializer
    ../../../../../../Middlewares/Third_Parties/AzureIOT/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c schemaserializer.c
  group Middlewares/LibNDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_NDEF.c lib_NDEF_Wifi.c lib_TagType4.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Parties/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64_2.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1_2.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version_2.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
  group Middlewares/STM32_SPWF01SA/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
